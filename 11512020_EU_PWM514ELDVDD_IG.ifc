Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-06-02T11:25:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 02 11:25:58 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{21FE6A15-C70E-4F3F-88DF-F13265524B78}\ifc * Database version: 5507 * Database creation date: Wed Jun 02 11:25:57 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 02 11:25:57 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 02 11:25:57 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 51514001_EU_11512020_PWM514ELDVDD_IG, 11512020_EU_PWM514ELDVDD_IG:51514001_EU_11512020_PWM514ELDVDD_IG:208858
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Stainless_Steel, Rubber, Black, z_Miele_Design_Glass, z_Miele_Connection_Electric, z_Miele_Design_Glass Black, z_Miele_Design_Iron_Grey, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Water_IN, z_Miele_Connection_Network, z_Miele_Connection_Water_OUT, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 51514001_EU_11512020_PWM514ELDVDD_IG
